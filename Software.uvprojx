# Keil uVision project Software.uvprojx, settings and files
target Software (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Software +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: Inc;Drivers/STM32F1xx_HAL_Driver/Inc;Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;Drivers/CMSIS/Device/ST/STM32F1xx/Include;Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/Src
    Src/: main.c stm32f1xx_it.c midi_in.c midi_test.c UI.c ym3812_hal.c initialization.c gpio.c template.c uart.c system_clock.c stm32f1xx_hal_msp.c
    ./Src/: us_timer.c ym3812_contol.c
  group Drivers/STM32F1xx_HAL_Driver
    Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    Src/: system_stm32f1xx.c
  group Application/Inc
    Inc/: main.h midi_in.h midi_test.h stm32f1xx_hal_conf.h stm32f1xx_it.h UI.h ym3812_hal.h initialization.h gpio.h template.h uart.h system_clock.h global.h
    ./Inc/: us_timer.h ym3812_control.h instruments.h midi_drums.h midi_instruments.h
software components: CMSIS:CORE 5.6.0
